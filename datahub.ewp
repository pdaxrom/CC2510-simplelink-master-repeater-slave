# IAR project datahub.ewp, settings and files
configuration EndDevice (8051)
  General.OGChipSelectMenu: CC2510F32 CC2510F32
  ICC8051.CCDefines: MCU_H="ioCC2511.h"; MRFI_CC2511
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Components\bsp; Components\bsp\drivers; Components\bsp\boards\RFUSB; Components\mrfi; Components\SimpliciTI\nwk; Components\SimpliciTI\nwk_applications
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2510F32.xcl
configuration Repeater (8051)
  as the first configuration, except:
configuration Datahub (8051)
  as the first configuration, except:
  group (top)
    ./: main_datahub.c main_enddevice.c main_repeater.c max7219.c max7219.h
  group Components/bsp
    Components/bsp/: bsp.c
  group Components/mrfi
    Components/mrfi/: mrfi.c
  group Components/nwk
    Components/simpliciti/nwk/: nwk.c nwk_api.c nwk_frame.c nwk_globals.c nwk_QMgmt.c
  group Components/nwk_application
    Components/simpliciti/nwk_applications/: nwk_freq.c nwk_ioctl.c nwk_join.c nwk_link.c nwk_mgmt.c nwk_ping.c nwk_pll.c nwk_security.c
